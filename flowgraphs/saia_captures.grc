options:
  parameters:
    author: hark
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: saia_captures
    output_language: python
    title: SAIA Captures
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 119.6e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      SAT   San Antonio International Airport (KSAT)
      SKF   Kelly Field, Lackland AFB / Port San Antonio (KSKF)
      SSF   Stinson Municipal Airport (KSSF)

      ATIS  Automatic Terminal Information Service (recorded weather/runway loop)
      CLNC  Clearance Delivery (IFR route clearances before taxi)
      GND   Ground Control (taxiways and ramp, not runways)
      TWR   Tower / Local Control (runways; takeoff and landing clearances)
      APP   Approach Control (arrivals; San Antonio TRACON)
      DEP   Departure Control (departures; San Antonio TRACON)

      TRACON  Terminal Radar Approach Control (facility that runs APP and DEP)
    gui_hint: 1,0,1,10
    label: Frequency
    labels: '[''SAT ATIS 118.9'', ''SAT CLNC 126.7'', ''SAT GND 121.9'', ''SAT TWR 119.8'', ''SAT APP 118.05'', ''SAT APP 124.45'', ''SAT APP 125.1'', ''SAT APP 128.05'', ''SAT APP 127.1'', ''SAT/SSF APP-DEP 125.7'', ''SKF ATIS 120.45'', ''SKF GND 121.8'', ''SKF TWR 124.3'', ''SSF ATIS 128.8'', ''SSF GND 121.7'', ''SSF TWR 118.2'']'
    num_opts: '0'
    options: '[118.9e6, 126.7e6, 121.9e6, 119.8e6, 118.05e6, 124.45e6, 125.1e6, 128.05e6, 127.1e6, 125.7e6, 120.45e6, 121.8e6, 124.3e6, 128.8e6, 121.7e6, 118.2e6]'
    type: real
    value: 119.8e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'True'
    ramp: '0'
    threshold: '-100'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq-freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/decimation
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Hark
    center_freq: np.nan
    description: SAIA Capture
    filename: /home/hark/Repos/middle-key/data/middle_key_??_s48k_UPDATE_ME
    hw_info: Ettus USRP B206 mini
    sample_rate: samp_rate/decimation
    type: complex float (fc32_le)
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '128'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate/decimation
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Baseband"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    name: '"Filtered"'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"2. After DC Blocker"'
    size: '1024'
    srate: samp_rate/decimation
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"1. After Complex to Mag"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"3. After the audio LPF"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"4. Into the Audio Sink"'
    size: '1024'
    srate: samp_rate/decimation
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: raw_audio
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: filtered_channel
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: raw_audio
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: filtered_channel
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', virtual_sink_1, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_2, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', low_pass_filter_1, '0']
- [virtual_source_1, '0', analog_pwr_squelch_xx_0, '0']
- [virtual_source_1, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
